<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OTGH_CDC_FS2.ewp</path>
    </project>
    <batchBuild />
</workspace>
