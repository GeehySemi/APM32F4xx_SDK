<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\QSPI_ReadWriteInterrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
