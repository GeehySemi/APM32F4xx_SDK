# IAR project Template.ewp, settings and files
configuration APM32F427 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F427xG Geehy APM32F427xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: APM32F427xx; APM32F427_TINY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration APM32F425 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F425xG Geehy APM32F425xG
configuration APM32F423 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F423xG Geehy APM32F423xG
  General.FPU2: 4
  ICCARM.CCDefines: APM32F423xx; APM32F427_TINY
  group Application
    ../../Source/: apm32f4xx_int.c main.c
  group Boards
    ../../../../../../Boards/: Board.c
  group CMSIS
    ./: startup_apm32f423xx.s startup_apm32f425xx.s startup_apm32f427xx.s
    ../../Source/: system_apm32f4xx.c
  group Document
    ../../: readme.txt
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_eth.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
