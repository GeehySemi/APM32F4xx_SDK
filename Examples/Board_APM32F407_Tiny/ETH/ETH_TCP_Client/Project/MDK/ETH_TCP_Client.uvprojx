# Keil uVision project ETH_TCP_Client.uvprojx, settings and files
target APM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ETH_TCP_Client
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F407xx,APM32F407_TINY,PHY_SR=31,PHY_DUPLEX_STATUS=0x0010,PHY_SPEED_STATUS=0x0004
  c include: ..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\..\Boards\Board_APM32F407_Tiny\inc;..\..\..\ETH_Ping;..\..\..\..\..\..\Middlewares\LwIP\src\include;..\..\..\..\..\..\Middlewares\LwIP\src\include\lwip;..\..\..\..\..\..\Middlewares\LwIP\src\include\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ./: startup_apm32f407xx.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_eth.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
  group Boards
    ../../../../../../Boards/: Board.c
    ../../Source/: board_lan8720a.c
    ../../../../../../Boards/Board_APM32F427_Tiny/src/: board_delay.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c ethernetif.c echo_c.c
  group lwip
    ../../../../../../Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../Middlewares/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../Middlewares/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../Middlewares/LwIP/src/netif/: ethernet.c
  group Document
    ../../: readme.txt
