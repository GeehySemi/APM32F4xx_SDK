<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DSP_graphic_equalizer.ewp</path>
    </project>
    <batchBuild />
</workspace>
