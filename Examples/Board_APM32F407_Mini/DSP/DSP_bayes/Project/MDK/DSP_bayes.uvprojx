# Keil uVision project DSP_bayes.uvprojx, settings and files
target APM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSP_bayes
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F407xx,APM32F407_MINI
  c include: ..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\..\Boards\Board_APM32F407_Mini\inc;..\..\..\..\..\..\Libraries\CMSIS\DSP\Include;..\..\..\..\..\..\Libraries\CMSIS\DSP\PrivateInclude
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ./: startup_apm32f407xx.s startup_apm32f417xx.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_eth.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
  group Boards
    ../../../../../../Boards/: Board.c
    ../../../../../../Boards/Board_APM32F407_Mini/src/: board_delay.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c arm_bayes_example_f32.c
  group DSP_Lib
    ../../../../../../Libraries/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../../../../../Libraries/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c
    ../../../../../../Libraries/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
  group Document
    ../../: readme.txt
target APM32F417 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F417IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: as above
  output: DSP_bayes
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F417xx,APM32F407_MINI
  c include: ..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\..\Libraries\CMSIS\DSP\Include;..\..\..\..\..\..\Libraries\CMSIS\DSP\PrivateInclude;..\..\..\..\..\..\Boards\Board_APM32F407_Mini\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
