# IAR project OTGH_DynamicSwitch.ewp, settings and files
configuration APM32F407 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F407IG Geehy APM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F407xx; APM32F407_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Boards; ..\..\..\..\..\..\..\Boards\Board_APM32F407_Mini\inc; ..\..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Core\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\CDC\Inc; ..\..\Fat_Fs; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\HID\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\MSC\Inc; ..\..\..\..\..\..\..\Middlewares\FatFs\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTGH_DynamicSwitch.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration APM32F417 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F417IG Geehy APM32F417IG
  ICCARM.CCDefines: APM32F417xx; APM32F407_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Boards; ..\..\..\..\..\..\..\Boards\Board_APM32F407_Mini\inc; ..\..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Core\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\CDC\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\HID\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\MSC\Inc; ..\..\..\..\..\..\..\Middlewares\FatFs\source; ..\..\Fat_Fs
  group Application
    ../../Source/: apm32f4xx_int.c fatfs.c main.c
  group Application/FATFS/App
    ../../../../../../../Middlewares/FatFs/source/: diskio.c
    ../../Fat_Fs/: usbh_diskio.c
  group Application/USB_HOST/App
    ../../Source/: usb_host_user.c
  group Application/USB_HOST/Config
    ../../Source/: usbh_board.c
  group Boards
    ../../../../../../../Boards/: Board.c
    ../../../../../../../Boards/Board_APM32F407_Mini/src/: board_delay.c log_printf.c
  group CMSIS
    ./: startup_apm32f407xx.s startup_apm32f417xx.s
    ../../Source/: system_apm32f4xx.c
  group Document
    ../../: readme.txt
  group Middlewares/FatFs
    ../../../../../../../Middlewares/FatFs/source/: ff.c ffsystem.c ffunicode.c
  group Middlewares/USB_Host_Library
    ../../../../../../../Middlewares/USB_Library/Host/Core/Src/: usbh_channel.c usbh_core.c usbh_dataXfer.c usbh_enum.c usbh_stdReq.c
  group Middlewares/USB_Host_Library/Class
    ../../../../../../../Middlewares/USB_Library/Host/Class/CDC/Src/: usbh_cdc.c
    ../../../../../../../Middlewares/USB_Library/Host/Class/HID/Src/: usbh_hid.c usbh_hid_keyboard.c usbh_hid_mouse.c
    ../../../../../../../Middlewares/USB_Library/Host/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group StdPeriphDriver
    ../../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_eth.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
