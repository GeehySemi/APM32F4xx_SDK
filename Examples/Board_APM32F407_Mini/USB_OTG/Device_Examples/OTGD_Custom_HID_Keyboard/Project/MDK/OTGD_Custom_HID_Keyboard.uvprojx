# Keil uVision project OTGD_Custom_HID_Keyboard.uvprojx, settings and files
target APM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OTGD_Custom_HID_Keyboard
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F407xx,APM32F407_MINI
  c include: ..\..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Class\CustomHID\Inc;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Core\Inc;..\..\..\..\..\..\..\Boards\Board_APM32F407_Mini\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ./: startup_apm32f407xx.s startup_apm32f417xx.s
  group StdPeriphDriver
    ../../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_eth.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
  group Boards
    ../../../../../../../Boards/: Board.c
    ../../../../../../../Boards/Board_APM32F407_Mini/src/: log_printf.c board_delay.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c
  group Application/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_custom_hid_if.c usbd_descriptor.c
  group Application/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/USB_Library/Device/Class/CustomHID/Src/: usbd_customhid.c
  group Document
    ../../: readme.txt
target APM32F417 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F417IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: as above
  output: OTGD_Custom_HID_Keyboard
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F417xx,APM32F407_MINI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
