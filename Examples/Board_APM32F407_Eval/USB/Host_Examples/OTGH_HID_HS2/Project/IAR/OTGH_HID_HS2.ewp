# IAR project OTGH_HID_HS2.ewp, settings and files
configuration APM32F407 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F407IG Geehy APM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: APM32F407xx; APM32F407_EVAL
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Boards; ..\..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Core\Inc; ..\..\..\..\..\..\..\Boards\Board_APM32F407_Eval\inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\HID\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTGH_HID_HS2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: OTGH_HID_HS2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f4xx_int.c main.c
  group Application/USB_HOST
    ../../Source/: usb_host_user.c
  group Application/USB_HOST/Config
    ../../Source/: usbh_board.c
  group Boards
    ../../../../../../../Boards/: Board.c
    ../../../../../../../Boards/Board_APM32F407_Eval/src/: board_delay.c
  group CMSIS
    ./: startup_apm32f407xx.s
    ../../Source/: system_apm32f4xx.c
  group Document
    ../../: readme.txt
  group Middlewares/USB_Host_Library
    ../../../../../../../Middlewares/USB_Library/Host/Core/Src/: usbh_channel.c usbh_core.c usbh_dataXfer.c usbh_enum.c usbh_stdReq.c
  group Middlewares/USB_Host_Library/Class
    ../../../../../../../Middlewares/USB_Library/Host/Class/HID/Src/: usbh_hid.c usbh_hid_keyboard.c usbh_hid_mouse.c
  group StdPeriphDriver
    ../../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_comp.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_eth.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
