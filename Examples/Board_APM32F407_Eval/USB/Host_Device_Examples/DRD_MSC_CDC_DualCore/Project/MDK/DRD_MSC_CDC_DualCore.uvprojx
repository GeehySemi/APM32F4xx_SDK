# Keil uVision project DRD_MSC_CDC_DualCore.uvprojx, settings and files
target APM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DRD_MSC_CDC_DualCore
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F407xx,APM32F407_EVAL
  c include: ..\..\..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\..\Boards;..\..\..\..\..\..\..\Boards\Board_APM32F407_Eval\inc;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Class\CDC\Inc;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Core\Inc;..\..\Include;..\..\Fat_Fs;..\..\..\..\..\..\..\Middlewares\FatFs\source;..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\MSC\Inc;..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ./: startup_apm32f407xx.s
  group StdPeriphDriver
    ../../../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_comp.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_eth.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
  group Boards
    ../../../../../../../Boards/: Board.c
    ../../../../../../../Boards/Board_APM32F407_Eval/src/: board_delay.c
  group Application
    ../../Source/: fatfs.c apm32f4xx_int.c main.c user_control.c
  group Application/USB_Device
    ../../Source/: usb_device_user.c usbd_cdc_vcp.c usbd_descriptor.c
  group Application/USB_Host
    ../../Source/: usb_host_user.c
  group Application/USB/Config
    ../../Source/: usbd_board.c usbh_board.c
  group Application/FATTS
    ../../Fat_Fs/: usbh_diskio.c
    ../../../../../../../Middlewares/FatFs/source/: diskio.c
  group Middlewares/Fatfs
    ../../../../../../../Middlewares/FatFs/source/: ff.c ffsystem.c ffunicode.c
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/USB_Library/Device/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/USB_Host_Library
    ../../../../../../../Middlewares/USB_Library/Host/Core/Src/: usbh_channel.c usbh_core.c usbh_dataXfer.c usbh_enum.c usbh_stdReq.c
  group Middlewares/USB_Host_Library/Class
    ../../../../../../../Middlewares/USB_Library/Host/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Document
    ../../: readme.txt
